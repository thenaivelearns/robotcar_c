# Keil uVision project Encoder for motor.uvprojx, settings and files
target Encoder for motor (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\TIMER_ENCODER;..\HARDWARE\KEY;..\HARDWARE\PID;..\HARDWARE\REMOTE;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\BEEP;..\HARDWARE\ATIMER;..\HARDWARE\OTIMER;..\HARDWARE\LINEFOLLOW;..\HARDWARE\INFRARED;..\HARDWARE\STEPMOTOR;..\STRATEGY;..\HARDWARE\ARM;..\HARDWARE\ULTRASOUND
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group HARDWARE
    ../HARDWARE/TIMER_ENCODER/: timer_encoder.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/ATIMER/: atimer.c
    ../HARDWARE/OTIMER/: otimer.c
    ../HARDWARE/LINEFOLLOW/: linefollow.c
    ../HARDWARE/INFRARED/: infrared.c
    ../HARDWARE/STEPMOTOR/: stepmotor.c
    ../HARDWARE/ARM/: arm.c
    ../HARDWARE/ULTRASOUND/: ultrasound.c
  group STATEGY
    ../STRATEGY/: strategy.c
